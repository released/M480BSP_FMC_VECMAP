LOAD_ROM_1  0x00000 0x40000
{
	app_bank1.bin  0x00000 0x40000
	{
		startup_M480.o (RESET, +FIRST)
        .ANY (+RO)
	}
	
	SRAM  0x20000000 0x28000
	{
		* (+RW, +ZI)
	}
}

